# Keil uVision project JM24022.uvproj, settings and files
target JM24022 (MCS-51)
  device: TM52F1376 tenx
  cpu: IRAM(0-0xFF) CLOCK(18000000) XRAM(0xFD00-0xFFFF)
  output: JM24022 +hex
  AfterMake: D:\项目\Y009\4.Code\023CODE_9.19\_Make_JM24022\run.bat
  c flags: Optimize=6 SizeSpeed=1
  c include: .\Drivers\inc;.\Drivers\src;.\src;.\inc;.\inc
  group driver
    ./Drivers/src/: TM52F1376_bsp.c TM52F1376_calc_bsp.c
  group src
    ./src/: main.c Peripheral.c AdcFunction.c BatteryFunction.c SubFunction.c SmokeFunction.c LedFunction.c KeyMicFunction.c
